# Keil uVision project h743_hal.uvprojx, settings and files
target h743_hal (6070000::V6.7::.\ARMCLANG)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: h743_hal +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx,ARM_MATH_CM7, __FPU_PRESENT=1
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Hardware;../Drivers/CMSIS/DSP/Include;../SignalProcess;../SignalProcess/long_fft;../MyDrive;../Tasks
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\h743_hal_h743_hal.sct
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Tasks
    ../Tasks/: Tasks.c Tasks.h sample_app_task_scheduler.c sample_app_task_scheduler.h
  group SignalProsess
    ../SignalProcess/: fftana.c fftana.h hanning_window.h
  group MyDrive
    ../MyDrive/: AD9910.c AD9910.h AD9959.c AD9959.h bsp_system.h delay.h Get_Freq.c Get_Freq.h HMI.c HMI.h sys.h delay.c
  group long_fft
    ../SignalProcess/long_fft/: arm_bitreversal2_extra.c arm_cfft_f32_extra.c arm_cfft_init_f32_extra.c arm_common_tables_extra.c arm_common_tables_extra.h arm_const_structs_extra.c arm_const_structs_extra.h arm_cortexM7l_math.lib arm_rfft_fast_f32_extra.c arm_rfft_fast_init_f32_extra.c extra_ffts.h
software components: CMSIS:CORE 5.6.0
